# Keil uVision project Plant_Monitor_STM32WB55.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00030000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: Plant_Monitor_STM32WB55
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group Source
    ./: main.c bsp.c
  group Includes
    ./: bsp.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
